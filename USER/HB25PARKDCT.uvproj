# Keil uVision project HB25PARKDCT.uvproj, settings and files
target HB25PARKDCT (ARM-ADS)
  device: NUC230LE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: HB25PARKDCT
  c flags: Optim=1
  c include: ..\NUC230_240_FWLib\inc;..\HARDWARE\inc;..\CMSIS\Include;..\CMSIS\NUC230_240\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --entry Reset_Handler
  group CMSIS
    ../CMSIS/NUC230_240/Source/: system_NUC230_240.c
    ../CMSIS/NUC230_240/Source/ARM/: startup_NUC230_240.s
  group USER
    ./: main.c
  group NUC230_240 FWlib
    ../NUC230_240_FWLib/src/: acmp.c adc.c can.c clk.c crc.c ebi.c fmc.c gpio.c i2c.c i2s.c pdma.c ps2.c pwm.c retarget.c rtc.c sc.c scuart.c spi.c sys.c timer.c uart.c usbd.c wdt.c wwdt.c
  group HARDWARE
    ../HARDWARE/src/: bsp.c bsp_can.c bsp_IO.c
